## base_external/Config.in
```kconfig
source "$BR2_EXTERNAL_project_base_PATH/home/badu/assignment-4-paulbobin/base_external/package/aesd-assignments/Config.in"
```
